# Keil uVision project STM32F103ZET6.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\User\HARDWARE\inc;..\Libraries\FWlib\inc;..\Libraries\CMSIS;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\User\TASK
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_crc.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c FreeRTOSConfig.h sys.h sys.c
  group TASK
    ../User/TASK/: FreeRTOS_demo.c FreeRTOS_demo.h
  group HARDWARE
    ../User/HARDWARE/src/: usart.c delay.c key.c led.c
  group FreeRTOS_CORE
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group DOC
    ../Doc/: readme.txt

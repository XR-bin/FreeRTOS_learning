# Keil uVision project My_FreeRTOS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: My_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freeRTOS\include;..\freeRTOS\protable\RVDS\ARM_CM3;..\freeRTOS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group freeRTOS/Port
    ../freeRTOS/protable/RVDS/ARM_CM3/: port.c
  group freeRTOS/Source
    ../freeRTOS/: list.c task.c
    ../freeRTOS/include/: FreeRTOSConfig.h portmacro.h FreeRTOS.h portable.h list.h task.h projdefs.h
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
